
PACKAGECONFIG_append = " opusparse"
